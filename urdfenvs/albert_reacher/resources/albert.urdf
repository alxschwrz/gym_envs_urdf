Commit message: URDF file change. changed mass of albert base to super highl value

File: urdfenvs/albert_reacher/resources/albert.urdf (robot description, URDF)
Before this commit: robot albert, 27 links, 26 joints
Links:
- link chassis_link: mass 250 -> 50000
